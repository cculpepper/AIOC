# Repository cculpepper/AIOC

## KiCad design kicad/k1-aioc/k1-aioc.kicad_pcb

Parts:
C1, C2: 22p/NP0; C_0402_1005Metric; LCSC C1555
C3, C8, C9, C12, C15: 100n; C_0402_1005Metric; LCSC C307331
C4, C5, C6, C7, C10, C13, C14: 4.7u/10V/X5R; C_0603_1608Metric; LCSC C19666
C11: 10n/NP0; C_0402_1005Metric; LCSC C15195
D1: GREEN; LED_0603_1608Metric; LCSC C72043
D2: RED; LED_0603_1608Metric; LCSC C2286
D3, D4: N.M.; LED_0603_1608Metric
FB1, FB2: 600R@100MHz; L_0603_1608Metric; LCSC C1002
H1, H2: ToolingHole; TOOLING-HOLE
H3, H4: MountingHole_Pad; MountingHole_2.2mm_M2_ISO14580_Pad_TopBottom
H5, H6, H7, H8, H9, H10, H12, H13, H14, H15: Breakaway Hole; breakawayHole
J1: 12401832E402A; USB_C_Receptacle_Amphenol_12401832E40-2A; LCSC C464604
J3: FT817-CAT; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
J4: FT817-CAT; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J5: USB; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J6: Conn_ARM_SWD_TagConnect_TC2030-NL; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
Q1, Q3, Q4: MMBT3904; SOT-23
R1: 1.5K; R_0402_1005Metric; LCSC C25867
R2: 10K; R_0402_1005Metric; LCSC C25744
R3, R6, R7, R16: 5.1K; R_0402_1005Metric; LCSC C25905
R4, R8, R9, R15: 220R; R_0402_1005Metric; LCSC C25091
R5, R10, R11, R14, R20: 2.2K; R_0402_1005Metric; LCSC C25879
R12, R13, R18, R21, R22, R23: 22R; R_0402_1005Metric; LCSC C25092
R17, R19: DNP; R_0402_1005Metric
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP11, TP12, TP13: TestPoint; TestPoint_Pad_1.0x1.0mm
U1: MIC5330-SSYML; Micrel_MLF-8-1EP_2x2mm_P0.5mm_EP0.6x1.2mm; LCSC C144168
U2: STM32F373CBTx; LQFP-48_7x7mm_P0.5mm; LCSC C94046
Y1: 8MHz/20pF; Crystal_SMD_5032-2Pin_5.0x3.2mm; LCSC C115962

Connections:
+3.3VA: C9.1, C10.1, FB1.1, R16.1, U2.9 (VDDA), U2.24 (VDDSD), U2.25 (VREFSD+)
+3V3: C4.1, C7.1, C8.1, J6.1 (VCC), JP1.1 (A), R1.1, U1.8 (VOUT1), U2.1 (VBAT), U2.17 (VDD), U2.36 (PF7), U2.48 (VDD)
/817_PTT: R20.2, U2.4 (PC15)
/817_RX: R23.2, U2.42 (PB6)
/817_TX: R22.2, U2.43 (PB7)
/AFIN: C11.1, R3.2, R5.1, R16.2, U2.20 (PB2)
/AFOUT: R2.2, U2.14 (PA4)
/BOOT0: JP1.2 (B), R14.2, U2.44 (BOOT0)
/DAC_ATTEN: R17.2, U2.13 (PA3)
/NRST: C15.1, J6.3 (~RESET), U2.7 (NRST)
/OSCIN: C1.1, U2.5 (PF0), Y1.1
/OSCOUT: C2.1, U2.6 (PF1), Y1.2
/PTT1: R11.1, U2.11 (PA1)
/PTT2: R10.1, U2.10 (PA0)
/RADIO-MIC: C13.2, J4.1
/RADIO-RX-PTT1: R8.1, R13.1
/RADIO-SPK: C14.2, R18.2, R19.1
/RADIO-TX: R9.1
/RADIO-VP-PTT2: R12.1
/SWCLK: J6.4 (SWCLK), U2.37 (PA14)
/SWDIO: J6.2 (SWDIO), U2.34 (PA13)
/SWO: J6.6 (SWO), U2.39 (PB3)
/USART-RX: R9.2, U2.31 (PA10)
/USART-TX: R8.2, U2.30 (PA9)
/USB-DN: J1.A7 (D-), J1.B7 (D-), J5.2, U2.32 (PA11)
/USB-DP: J1.A6 (D+), J1.B6 (D+), J5.3, R1.2, U2.33 (PA12)
/VBUS: FB2.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J5.1
/VIN: C6.1, FB2.1, U1.1 (VIN), U1.4 (EN2), U1.5 (EN1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C15.2, H3.1, H4.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J3.3, J4.4, J5.4, J6.5 (GND), Q1.2 (E), Q3.2 (E), Q4.2 (E), R3.1, R4.1, R6.1, R7.1, R14.1, R19.2, U1.2 (GND), U1.9 (GND), U2.8 (VSSA), U2.23 (VSSSD), U2.35 (PF6), U2.47 (VSS)
unnamed: C12.1, C13.1, R2.1, R4.2, R17.1
unnamed: C14.1, R5.2
unnamed: D1.2 (A), D2.1 (K), D3.2 (A), D4.1 (K), U2.46 (PB9)
unnamed: D1.1 (K), D2.2 (A), D3.1 (K), D4.2 (A), R15.1
unnamed: J1.A5 (CC1), R7.2
unnamed: J1.B5 (CC2), R6.2
unnamed: J3.1, R23.1
unnamed: J3.2, R22.1
unnamed: J4.2, R18.1
unnamed: J4.3, R21.1
unnamed: Q1.1 (B), R10.2
unnamed: Q1.3 (C), R12.2
unnamed: Q3.1 (B), R11.2
unnamed: Q3.3 (C), R13.2
unnamed: Q4.1 (B), R20.1
unnamed: Q4.3 (C), R21.2
unnamed: C3.1, U1.3 (BYP)
unnamed: C5.1, FB1.2, U1.7 (VOUT2)
unnamed: TP13.1, U2.12 (PA2)
unnamed: TP1.1, U2.15 (PA5)
unnamed: TP2.1, U2.16 (PA6)
unnamed: TP3.1, U2.29 (PA8)
unnamed: TP4.1, U2.38 (PA15)
unnamed: TP5.1, U2.18 (PB0)
unnamed: TP6.1, U2.19 (PB1)
unnamed: TP7.1, U2.40 (PB4)
unnamed: TP8.1, U2.41 (PB5)
unnamed: R15.2, U2.45 (PB8)
unnamed: TP11.1, U2.26 (PB14)
unnamed: TP12.1, U2.27 (PB15)

Notes on the sheet:
TXD RXD ALC GND
Short Pins for Bootloader
SDADC1_AIN4P/ADC2_IN12
USART1-TX
K connector consists of two TRS connectors (3.5mm and 2.5mm) spaced 12mm apart Upper connector (2.5mm) T: SPK+ R: TxData (from Radio) S: GND Lower connector (3.5mm) T: +V/PTT2 R: MIC+ S: PTT1/RxData (to Radio)
GPIOA P.P.
DAC1_OUT1
GPIOA O.D.
Compatible to STM32F302CBTx (no DS-ADC)
USART1-RX

Board: 4 copper layers, 21.0 x 41.5 mm, 81 parts (16 on the bottom side), 57 nets.

## Commit log

2023-08-31 Upgraded to latest version
2023-09-02 Added pin headers for 817
2023-09-03 Board mostly done. Added 817 connectors
2023-09-05 Commit before assembly
